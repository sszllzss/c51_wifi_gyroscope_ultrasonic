# Keil uVision project project.uvproj, settings and files
target Project (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\application;..\device
  group application
    ../application/: main.c SysInit.c ultrasonic.c
  group start
    ./: STARTUP.A51
  group device
    ../device/: gpio.c delay.c timer.c usart.c pca.c exti.c i2c.c 24cxx.c mpu6050.c led.c separate_key.c
